require fobnail-base-image.inc

IMAGE_FEATURES += "debug-tweaks"
