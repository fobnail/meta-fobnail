SRC_URI += " \
           file://kexec.cfg \
"
